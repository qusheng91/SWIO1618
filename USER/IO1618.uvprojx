# Keil uVision project IO1618.uvprojx, settings and files
target IO1618 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IO1618 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  ..\OBJ\IO1618.bin ..\OBJ\IO1618.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\sys;..\STMFWLIB\inc;..\CORE;..\HARDWARE\LIBDI;..\HARDWARE\LIBDO;..\HARDWARE\DELAY;..\HARDWARE\LIBCAN;..\HARDWARE\LIBTIMER;..\HARDWARE\LIBUSART;..\HARDWARE\LIBVAR;..\HARDWARE\LIBEEPROM;..\HARDWARE\LIBWATCHDOG;..\HARDWARE\LED;..\APPLICATION
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c LibLpc.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_cl.s
  group HARDWARE
    ../HARDWARE/LIBVAR/: LibVarDefine.c
    ../HARDWARE/LIBDI/: LibDI.c
    ../HARDWARE/LIBDO/: LibDO.c
    ../HARDWARE/DELAY/: delay.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LIBCAN/: LibCAN.c lib_can_queue.c
    ../HARDWARE/LIBTIMER/: LibTimer.c
    ../HARDWARE/LIBEEPROM/: LibEeprom.c
    ../HARDWARE/LIBWATCHDOG/: LibWatchDog.c
    ../HARDWARE/LIBUSART/: serial.c
  group FWLIB
    ../STMFWLIB/src/: misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_pwr.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group APPLICATION
    ../APPLICATION/: AppMain.c
